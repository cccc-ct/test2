# Keil uVision project STM32WiFiESPDHT11TCPServer.uvprojx, settings and files
target STM32 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32WiFiESPDHT11TCPServer +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\CMSIS;..\..\IOTLIB\inc;..\..\USER\STM32WiFiESPDHT11TCPServer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../CMSIS/: core_cm3.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group IOTLIB
    ../../IOTLIB/src/: delay.c dht11.c misc.c relay.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c sys.c usart.c cJSON.c esp8266.c led.c MqttKit.c tcpserver.c
  group STARTUP
    ../../CMSIS/startup/arm/: startup_stm32f10x_md.s
